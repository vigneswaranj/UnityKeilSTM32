# Keil uVision project UnityExample.uvproj, settings and files
target RetargetSTM32 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: UnityForSTM32 +hex
  c flags: Optim=1
  c define: STM32F10X_MD __DBG_ITM
  c include: C:\Keil\ARM\Inc\ST\STM32F10x\;.\CMSIS\Headers;.\Headers;D:\Unity\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ./Source/: system_stm32f10x.c startup_stm32f10x_cl.s
  group Main
    ./Source/: Projectmain.c
  group Support
    ./Source/: Retarget.c Serial.c
  group Documentation
    ./: ReadMe.txt
  group Unity
    D:/Unity/src/: unity.c
  group Tests
    ./Source/: Test.c
